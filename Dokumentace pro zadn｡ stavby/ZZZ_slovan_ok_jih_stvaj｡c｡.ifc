Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Y:\A-18-18 Slovan prosklení\190506_slovan_ok_jih_stávající.ifc
Time: 2019-05-06T19:29:43
Author: Vít Hušek
Written by: EDMsix Version 2.0100.03 Feb 3 2016
Made in: Allplan 2017.1 19.09.2018 - 11:13:58

# IfcBeam (3145)
In: Sestava
Material: <Unnamed Material>
Allplan Attributes - Jednotka: m3; Práce: Betonářské práce; IFC-Objekttyp: IfcBeam
Name | Allright_Stavebni_dil_ID | Označení | NOI_UUID
L60/6 | 0110ExE0000000684 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000686 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000687 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000688 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000689 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000691 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000692 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000693 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000694 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000695 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000698 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000700 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000701 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000702 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000703 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000706 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000708 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000709 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000710 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000711 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000712 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000713 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000714 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000716 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000718 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000719 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000720 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000722 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000723 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000760 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000761 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000762 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000763 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000764 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000765 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000875 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000876 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000877 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000878 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000879 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000880 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000881 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000882 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000883 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000884 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000885 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000886 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000887 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000888 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000889 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000890 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000891 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000892 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000893 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000894 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000895 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000896 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000897 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000898 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000899 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000900 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000901 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000902 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000903 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000904 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000905 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000906 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000907 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000908 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000909 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000910 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000911 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000912 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000913 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000914 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000915 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000916 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000917 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000918 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000919 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000920 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000921 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000922 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000923 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000924 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000925 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
L60/6 | 0110ExE0000000926 | L60/6 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000927 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000928 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P8 | 0110ExE0000000929 | P8 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000930 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000931 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000932 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000933 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000934 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000935 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000936 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000937 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000938 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000939 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000940 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
PRŮMĚR 12 | 0110ExE0000000941 | PRŮMĚR 12 | 4e7f446d-ab03-43c9-bb39-d33cb91facc8--0
P20 | 0120ExE0000000484 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000497 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000488 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000500 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000503 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000490 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000509 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000522 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000473 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000482 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000526 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000534 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000535 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000537 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000539 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000541 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000544 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000546 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000548 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000560 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000561 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000562 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000563 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000564 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000565 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000566 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000567 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000570 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000571 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000580 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000581 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000582 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000583 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000584 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000585 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000586 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000587 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000588 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000617 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000618 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000619 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000620 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000621 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000622 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000623 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000624 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000625 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000626 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000627 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000628 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000629 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000630 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000631 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000632 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000633 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000634 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000635 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000655 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000656 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000657 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000658 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000659 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000660 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000661 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000662 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000663 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000664 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000665 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000666 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000667 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000668 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000669 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000670 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000671 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000672 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000673 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000694 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000695 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000696 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000697 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000699 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000700 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000693 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000698 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000701 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000702 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000703 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000704 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000705 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000706 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000707 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000708 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000709 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000710 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000711 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000782 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000783 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000784 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000785 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000786 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000787 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000788 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000789 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000814 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
U300 | 0120ExE0000000815 | U300 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000816 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000817 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000818 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000819 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000820 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000821 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000822 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000823 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000824 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE0000000849 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE0000000853 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045249 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045246 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045250 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045240 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE0000000858 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045252 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045262 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045263 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045264 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045265 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045266 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045267 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045268 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045269 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045286 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045287 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045288 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045289 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045290 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045291 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045292 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045293 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045302 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045303 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045304 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045305 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045306 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045307 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045308 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045309 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045310 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045311 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045312 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045313 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045314 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045315 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045316 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045317 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045318 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045319 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045320 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045321 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045322 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045323 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045324 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045325 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045326 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045327 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045328 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045329 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045330 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045331 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045332 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045333 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045334 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045335 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045336 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045337 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045338 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045339 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045340 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045341 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P30 | 0120ExE2132045342 | P30 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045343 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045344 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045345 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0120ExE2132045346 | P20 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
I160 | 0120ExE2132045347 | I160 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045348 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P12 | 0120ExE2132045349 | P12 | 414c57af-0b36-4128-b1fd-818064e7eb84--0
P20 | 0135ExE0000000410 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000411 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000314 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000332 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000000374 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000000383 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000236 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000233 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000229 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000222 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000366 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000372 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000430 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000438 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000408 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000428 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000450 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000458 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000441 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000443 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000447 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000445 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000359 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000364 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000389 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000412 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000413 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000426 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000440 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000442 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000210 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000238 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000328 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000137 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000341 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000239 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000388 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000067 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P30 | 0135ExE0000000119 | P30 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000522 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000523 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000000526 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000000527 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000530 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000531 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000533 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000534 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000535 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000536 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000537 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000538 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000539 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000000540 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000541 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000000542 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000543 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000544 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000545 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000546 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000548 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000549 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000550 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000551 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000552 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000553 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000556 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000557 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000563 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000528 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000000529 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000560 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000555 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000559 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000558 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000524 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000000525 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P30 | 0135ExE0000000567 | P30 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000565 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000883 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000893 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000897 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001085 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001086 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001087 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001088 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000001089 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000001090 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001091 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001092 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001093 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001094 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001096 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001097 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001098 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001099 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001100 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001101 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001102 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001103 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001104 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001105 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001106 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001107 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001108 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001109 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001111 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001112 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001113 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001114 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001115 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001116 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001118 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001119 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001120 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001121 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001122 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001123 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001126 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001128 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P30 | 0135ExE0000001130 | P30 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001177 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001178 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001181 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001182 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001183 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001184 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001185 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001186 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001188 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P30 | 0135ExE0000001190 | P30 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001191 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001192 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000001193 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000001194 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001195 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001196 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001198 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001199 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001200 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001201 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001202 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001203 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001204 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001205 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001206 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001207 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001208 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001209 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001210 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001211 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001213 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001214 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001215 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001216 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001217 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001218 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001219 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001220 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001223 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001226 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001227 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001229 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001230 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001231 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001232 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P30 | 0135ExE0000001233 | P30 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001234 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001235 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001236 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001237 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001242 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001246 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001338 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001344 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001345 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001346 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P20 | 0135ExE0000001347 | P20 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000001348 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L100/8 | 0135ExE0000001349 | L100/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001350 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001351 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001352 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001353 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001355 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001356 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001357 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001358 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001359 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001360 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001361 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L120/12 | 0135ExE0000001362 | L120/12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001363 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/10 | 0135ExE0000001364 | L80/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001365 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001366 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001367 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001368 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001370 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001371 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001372 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001373 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001374 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001375 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001377 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001378 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001379 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001380 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001381 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000001382 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001385 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000001387 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P30 | 0135ExE0000001389 | P30 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001224 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L90/10 | 0135ExE0000001225 | L90/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001410 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P8 | 0135ExE0000001481 | P8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001485 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001490 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P8 | 0135ExE0000001492 | P8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001494 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001499 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P8 | 0135ExE0000001501 | P8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001503 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001505 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P8 | 0135ExE0000001506 | P8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
L80/8 | 0135ExE0000001507 | L80/8 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000111 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000113 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000151 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002219 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002220 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002221 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002231 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002232 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002233 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002240 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002241 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002242 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002246 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002247 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002248 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002252 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002253 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002254 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002258 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002259 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002260 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002264 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002265 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002266 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002270 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000002271 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000002272 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000566 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P16 | 0135ExE0000000564 | P16 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
P12 | 0135ExE0000000554 | P12 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
TR198/10 | 0135ExE0000002811 | TR198/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
TR198/10 | 0135ExE0000003077 | TR198/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
TR198/10 | 0135ExE0000003083 | TR198/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
TR198/10 | 0135ExE0000003089 | TR198/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
TR198/10 | 0135ExE0000003091 | TR198/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
TR198/10 | 0135ExE0000003093 | TR198/10 | be9342ac-37d9-4f1f-a7e2-38fee754d574--0
UPE200 | 0140ExE0000000069 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000000075 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000101 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000082 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000109 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000114 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000097 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000086 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000132 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000125 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000136 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000139 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000142 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000143 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000144 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000145 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000151 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000154 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000160 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000161 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000162 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000163 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000164 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000165 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000166 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000167 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000168 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000169 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000172 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000208 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000209 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000210 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000211 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000212 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000215 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000221 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000222 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000223 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000224 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000226 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000239 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000249 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000251 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000253 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000255 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000257 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000258 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000252 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000254 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000256 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000250 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000275 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000276 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000281 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000285 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000286 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000287 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000288 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000289 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000290 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000291 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000292 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000293 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000000312 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000314 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000315 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000316 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000317 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000318 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000319 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000333 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000334 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000335 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000336 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000337 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000242 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000313 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000000393 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000000404 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000466 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000469 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000475 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000477 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000474 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000471 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000472 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000476 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000478 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000473 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000495 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000496 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000499 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000470 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000509 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000510 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000511 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000512 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000513 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000514 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000515 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000516 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000525 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000526 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000527 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000528 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000529 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000530 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000531 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000532 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000541 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000542 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000543 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000544 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000545 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000546 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000547 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000548 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000557 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000558 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000559 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000560 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000561 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000562 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000563 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000564 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000573 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000574 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000505 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000672 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000673 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000674 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000675 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000676 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000677 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000678 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000679 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000680 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000681 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000682 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000683 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000684 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000685 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000686 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000687 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000688 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000689 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000690 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000691 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000692 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000693 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000694 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L80/8 | 0140ExE0000000395 | L80/8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L80/8 | 0140ExE0000000723 | L80/8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000742 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000817 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000806 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000743 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000869 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000892 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000885 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000914 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000908 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000966 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000941 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000936 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000937 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000940 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000939 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000972 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000938 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000974 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000978 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000982 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000981 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000985 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000983 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000995 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001107 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001108 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001109 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001110 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001111 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001112 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000840 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000814 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000001150 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001152 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000818 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000001160 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001161 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001162 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000001163 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000887 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000886 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000000905 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000913 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000000917 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001184 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001185 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001186 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001188 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001192 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001195 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001202 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001203 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001204 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001205 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000001931 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000001932 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001933 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001934 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001935 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001936 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001937 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001938 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001939 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001940 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001941 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001942 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001943 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001944 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001945 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001946 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001947 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001948 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001949 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001950 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001951 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001952 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001953 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001954 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P12 | 0140ExE0000001955 | P12 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001956 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001957 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001958 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001959 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001960 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001961 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001962 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001963 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001964 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001965 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001966 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001967 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000001968 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000000232 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000000231 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000002301 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
UPE200 | 0140ExE0000002302 | UPE200 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000002303 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000002304 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000002305 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
P8 | 0140ExE0000002306 | P8 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
L60/6 | 0140ExE0000002307 | L60/6 | 0d8c8f65-61b6-4667-b1f4-82b37271562a--0
